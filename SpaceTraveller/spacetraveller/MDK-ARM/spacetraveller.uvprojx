# Keil uVision project spacetraveller.uvprojx, settings and files
target spacetraveller (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: spacetraveller
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xC
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F3xx_HAL_Driver/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F3xx/Include;..\Drivers\BSP\STM32F3-Discovery;..\Drivers\BSP\Components;..\Drivers\BSP\Components\Common
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ioreq.c usbd_ctlreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Application/MDK-ARM
    ./: startup_stm32f303xc.s
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_flash_ex.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_spi.c stm32f3xx_hal_i2c.c stm32f3xx_hal_tim.c stm32f3xx_hal_rtc.c stm32f3xx_hal_pcd.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_spi_ex.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c timers.c tasks.c event_groups.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/User
    ../Src/: usbd_desc.c main.c usbd_cdc_if.c usb_device.c spi.c i2c.c stm32f3xx_hal_msp.c gpio.c freertos.c stm32f3xx_hal_timebase_TIM.c stm32f3xx_it.c usbd_conf.c mems.c
  group Drivers/BSP/STM32F3-Discovery
    ../Drivers/BSP/STM32F3-Discovery/: stm32f3_discovery.c stm32f3_discovery_accelerometer.c stm32f3_discovery_gyroscope.c
  group Drivers/Components
    ../Drivers/BSP/Components/l3gd20/: l3gd20.c
    ../Drivers/BSP/Components/lsm303dlhc/: lsm303dlhc.c
software components: CMSIS:CORE 4.1.0
